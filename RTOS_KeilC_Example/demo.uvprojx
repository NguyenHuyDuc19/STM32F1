# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\Hardware\STM32F1\STM32F1_Lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
    D:/Hardware/STM32F1/STM32F1_Lib/: gpio.c gpio.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Coroutines 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Message Buffer 10.3.1, RTOS:Stream Buffer 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, Device:Startup 1.0.0
